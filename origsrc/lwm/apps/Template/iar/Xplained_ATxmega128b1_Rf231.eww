<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Xplained_ATxmega128b1_Rf231.ewp</path>
  </project>
</workspace>


