<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Rcb128rfa1_ATmega128rfa1.ewp</path>
  </project>
</workspace>


