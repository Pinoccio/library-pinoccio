<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Rcb256rfr2_ATmega256rfr2.ewp</path>
  </project>
</workspace>


