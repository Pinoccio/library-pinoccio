# IAR project Rcb231_ATmega1281_Rf231.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m1281 ATmega1281
  ICCAVR.CCDefines: PHY_AT86RF231; HAL_ATMEGA1281; PLATFORM_RCB231; F_CPU=8000000
  ICCAVR.newCCIncludePaths: ../../../hal/atmega1281/inc; ../../../phy/at86rf231/inc; ../../../nwk/inc; ../../../sys/inc; ../../../hal/drivers/atmega1281; ../../../service/inc; ..
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: %xcl_file%
configuration Release (AVR)
  as the first configuration, except:
  group (top)
    ../: otaInterface.c config.h WSNDemo.c
  group stack/sys/src
    ../../../sys/src/: sysEncrypt.c sysTimer.c sys.c
  group stack/sys/inc
    ../../../sys/inc/: sysTypes.h sysTimer.h sys.h sysEncrypt.h sysConfig.h
  group stack/phy/at86rf231/src
    ../../../phy/at86rf231/src/: phy.c
  group stack/phy/at86rf231/inc
    ../../../phy/at86rf231/inc/: phy.h at86rf231.h
  group stack/hal/drivers/atmega1281
    ../../../hal/drivers/atmega1281/: halLed.h halSleep.h halSleep.c halUart.h halUart.c
  group stack/hal/atmega1281/src
    ../../../hal/atmega1281/src/: halPhy.c halTimer.c hal.c
  group stack/hal/atmega1281/inc
    ../../../hal/atmega1281/inc/: halGpio.h hal.h halPhy.h halTimer.h
  group stack/service/src
    ../../../service/src/: otaClient.c
  group stack/service/inc
    ../../../service/inc/: otaCommon.h otaClient.h
  group stack/nwk/src
    ../../../nwk/src/: nwkRx.c nwk.c nwkRoute.c nwkRouteDiscovery.c nwkSecurity.c nwkFrame.c nwkGroup.c nwkDataReq.c nwkTx.c
  group stack/nwk/inc
    ../../../nwk/inc/: nwkTx.h nwkCommand.h nwkGroup.h nwkRouteDiscovery.h nwkRoute.h nwkDataReq.h nwk.h nwkSecurity.h nwkFrame.h nwkRx.h
