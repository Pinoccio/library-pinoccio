# IAR project XplainedPro_ATmega256rfr2.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m256rfr2 ATmega256RFR2
  ICCAVR.CCDefines: PHY_ATMEGA256RFR2; HAL_ATMEGA256RFR2; PLATFORM_XPLAINED_PRO; F_CPU=8000000
  ICCAVR.newCCIncludePaths: ../../../hal/atmega256rfr2/inc; ../../../phy/atmega256rfr2/inc; ../../../nwk/inc; ../../../sys/inc; ../../../hal/drivers/atmega256rfr2; ../../../service/inc; ..
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: %xcl_file%
configuration Release (AVR)
  as the first configuration, except:
  group (top)
    ../: otaInterface.c config.h WSNDemo.c
  group stack/sys/src
    ../../../sys/src/: sysEncrypt.c sysTimer.c sys.c
  group stack/sys/inc
    ../../../sys/inc/: sysTypes.h sysTimer.h sys.h sysEncrypt.h sysConfig.h
  group stack/phy/atmega256rfr2/src
    ../../../phy/atmega256rfr2/src/: phy.c
  group stack/phy/atmega256rfr2/inc
    ../../../phy/atmega256rfr2/inc/: atmega256rfr2.h phy.h
  group stack/hal/drivers/atmega256rfr2
    ../../../hal/drivers/atmega256rfr2/: halUart.h halSleep.h halUart.c halLed.h halSleep.c
  group stack/hal/atmega256rfr2/src
    ../../../hal/atmega256rfr2/src/: halTimer.c hal.c
  group stack/hal/atmega256rfr2/inc
    ../../../hal/atmega256rfr2/inc/: hal.h halGpio.h halTimer.h
  group stack/service/src
    ../../../service/src/: otaClient.c
  group stack/service/inc
    ../../../service/inc/: otaCommon.h otaClient.h
  group stack/nwk/src
    ../../../nwk/src/: nwkRx.c nwk.c nwkRoute.c nwkRouteDiscovery.c nwkSecurity.c nwkFrame.c nwkGroup.c nwkDataReq.c nwkTx.c
  group stack/nwk/inc
    ../../../nwk/inc/: nwkTx.h nwkCommand.h nwkGroup.h nwkRouteDiscovery.h nwkRoute.h nwkDataReq.h nwk.h nwkSecurity.h nwkFrame.h nwkRx.h
