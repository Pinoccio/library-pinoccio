<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Rcb231_ATmega1281_Rf231.ewp</path>
  </project>
</workspace>


