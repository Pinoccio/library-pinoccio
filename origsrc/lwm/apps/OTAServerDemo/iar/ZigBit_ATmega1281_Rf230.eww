<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ZigBit_ATmega1281_Rf230.ewp</path>
  </project>
</workspace>


